options:
  parameters:
    author: NV
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters:
    vlen: '1024'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: '1024'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\NV\Desktop\joint idn\polar+8psk.bin
    type: complex
    vlen: '1024'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Custom GNU Radio Python block:
          - Accepts vectors of 1024 complex64 samples
          - Extracts real and imag parts into 2048-length feature vector
          - Appends fixed label to each vector
          - Saves all to NPZ with 'features' and 'labels' arrays
          """

          def __init__(self, filename="output.npz", label=0):
              gr.sync_block.__init__(
                  self,
                  name="Labeled NPZ File Sink",
                  in_sig=[(np.complex64, 1024)],
                  out_sig=[]
              )

              self.filename = filename
              self.label = label
              self.features = []
              self.labels = []

          def work(self, input_items, output_items):
              in0 = input_items[0]  # Shape: (N, 1024)

              for vec in in0:
                  real = np.real(vec)
                  imag = np.imag(vec)
                  feature_vector = np.concatenate((real, imag))  # Shape: (2048,)
                  self.features.append(feature_vector)
                  self.labels.append(self.label)

              return len(in0)

          def stop(self):
              # Save features and labels to NPZ
              if self.features:
                  features_array = np.array(self.features, dtype=np.float32)  # Shape: (N, 2048)
                  labels_array = np.array(self.labels, dtype=np.int32)        # Shape: (N,)
                  np.savez(self.filename, features=features_array, labels=labels_array)
                  print(f"Saved {len(labels_array)} vectors to {self.filename}")
              return True
    filename: '"turbo64"'
    label: '9'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Custom GNU Radio Python block:
          - Accepts vectors of 1024 complex64 samples
          - Extracts real and imag parts into 2048-length feature vector
          - Appends fixed label to each vector
          - Saves all to NPZ with 'features' and 'labels' arrays
          """

          def __init__(self, filename="output.npz", label=0):
              gr.sync_block.__init__(
                  self,
                  name="Labeled NPZ File Sink",
                  in_sig=[(np.complex64, 1024)],
                  out_sig=[]
              )

              self.filename = filename
              self.label = label
              self.features = []
              self.labels = []

          def work(self, input_items, output_items):
              in0 = input_items[0]  # Shape: (N, 1024)

              for vec in in0:
                  real = np.real(vec)
                  imag = np.imag(vec)
                  feature_vector = np.concatenate((real, imag))  # Shape: (2048,)
                  self.features.append(feature_vector)
                  self.labels.append(self.label)

              return len(in0)

          def stop(self):
              # Save features and labels to NPZ
              if self.features:
                  features_array = np.array(self.features, dtype=np.float32)  # Shape: (N, 2048)
                  labels_array = np.array(self.labels, dtype=np.int32)        # Shape: (N,)
                  np.savez(self.filename, features=features_array, labels=labels_array)
                  print(f"Saved {len(labels_array)} vectors to {self.filename}")
              return True
    filename: '"conv64"'
    label: '9'
  states: {state: disabled}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          Custom GNU Radio Python block:
          - Accepts vectors of 1024 complex64 samples
          - Extracts real and imag parts into 2048-length feature vector
          - Appends fixed label to each vector
          - Saves all to NPZ with 'features' and 'labels' arrays
          """

          def __init__(self, filename="output.npz", label=0):
              gr.sync_block.__init__(
                  self,
                  name="Labeled NPZ File Sink",
                  in_sig=[(np.complex64, 1024)],
                  out_sig=[]
              )

              self.filename = filename
              self.label = label
              self.features = []
              self.labels = []

          def work(self, input_items, output_items):
              in0 = input_items[0]  # Shape: (N, 1024)

              for vec in in0:
                  real = np.real(vec)
                  imag = np.imag(vec)
                  feature_vector = np.concatenate((real, imag))  # Shape: (2048,)
                  self.features.append(feature_vector)
                  self.labels.append(self.label)

              return len(in0)

          def stop(self):
              # Save features and labels to NPZ
              if self.features:
                  features_array = np.array(self.features, dtype=np.float32)  # Shape: (N, 2048)
                  labels_array = np.array(self.labels, dtype=np.int32)        # Shape: (N,)
                  np.savez(self.filename, features=features_array, labels=labels_array)
                  print(f"Saved {len(labels_array)} vectors to {self.filename}")
              return True
    filename: '"polar64"'
    label: '9'
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    type: float
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"Real"'
    ymax: '1.25'
    ymin: '-1.25'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 3.5e5
    center_freq0: 2.4e9
    gain0: '40'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_complex_to_real_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0_1, '0']
- [digital_mpsk_snr_est_cc_0, '0', qtgui_number_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
